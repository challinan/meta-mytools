FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://kernel-print-cmdline-banner-late.patch"
